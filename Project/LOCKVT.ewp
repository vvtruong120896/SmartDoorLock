# IAR project LOCKVT.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER; STM8L05X_HD_VL
  ICCSTM8.CCIncludePath2: ..\Driver_ST\inc; ..\Driver_User\inc; ..\App; ..\Mid\common; ..\Mid\fingerprint; ..\Mid\ncp
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LOCKVT.hex
  ILINK.IlinkOutputFile: LOCKVT.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group App
    ../App/: fingerprint_app.c fingerprint_app.h zb_command.c zb_command.h
  group Driver_ST
    ../Driver_ST/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_pwr.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim4.c stm8l15x_usart.c
  group Driver_User/inc
    ../Driver_User/inc/: audio.h clock.h defaultdevicecode.h define.h definepin.h delay.h drivermotor.h eeprom.h exti.h getpassword.h leddisplay.h mainfunctionlist.h managerpower.h mfcv520.h sleep.h Softwaretimer.h sw_i2c.h timer.h tsm12.h uart.h
  group Driver_User/src
    ../Driver_User/src/: audio.c clock.c defaultdevicecode.c delay.c drivermotor.c eeprom.c exti.c getpassword.c leddisplay.c mainfunctionlist.c managerpower.c mfcv520.c sleep.c Softwaretimer.c sw_i2c.c timer.c tsm12.c uart.c
  group Mid/common
    ../Mid/common/: queue.c queue.h xor.c xor.h
  group Mid/fingerprint
    ../Mid/fingerprint/: fingerprint.c fingerprint.h
  group Mid/ncp
    ../Mid/ncp/: ncp.c ncp.h
  group Source
    ../Source/: Mainlock.c stm8l15x_it.c
